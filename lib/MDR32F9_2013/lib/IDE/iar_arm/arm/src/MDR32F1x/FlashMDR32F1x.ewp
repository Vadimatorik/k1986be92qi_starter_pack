# IAR project FlashMDR32F1x.ewp, settings and files
configuration FlashMDR32F1xRAM4K (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr MDR32F1x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashMDR32F1x.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$RAM4K.out
  ILINK.IlinkIcfFile: MDR32F1x4k.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashMDR32F1x.c readme.txt
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
