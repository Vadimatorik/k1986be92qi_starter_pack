# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: 1986be91_adc.h 1986be91_bkp.h 1986be91_can.h 1986be91_comp.h 1986be91_dac.h 1986be91_dma.h 1986be91_eeprom.h 1986be91_ext_bus_cntrl.h 1986be91_i2c.h 1986be91_iwdg.h 1986be91_port.h 1986be91_power.h 1986be91_rst_clk.h 1986be91_spi.h 1986be91_sys.h 1986be91_timer.h 1986be91_uart.h 1986be91_usb.h 1986be91_wwdg.h 1986be91t1.h cm3_macro.h core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h CortexM3.h cvt.c ee_printf.c Serial.c Serial.h startup_1986be9x.s system_1986ВЕ91T1.c
