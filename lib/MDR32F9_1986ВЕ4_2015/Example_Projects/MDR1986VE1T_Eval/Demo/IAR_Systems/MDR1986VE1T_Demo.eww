<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MDR1986VE1T_Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


