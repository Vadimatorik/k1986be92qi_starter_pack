# IAR project MDR1986VE1T_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE1T Milandr MDR1986VE1T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARM_CM1
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\Libraries\MDR32F9Qx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library; ..\..\..\..\Libraries\CMSIS\CM1\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc; ..\..\..\..\Libraries\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\iar; ..\..\..\..\Example_Projects\MDR1986VE1T_Eval\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MDR1986VE1T_Demo.hex
  ILINK.IlinkOutputFile: MDR1986VE1T_Demo.out
  ILINK.IlinkIcfFile: MDR1986VE1T.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group Fonts
    ../../fonts/: Font_12x16.c Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c
  group MDR32F9Qx_FatFsLib
    ../../src_fatfs/: diskio.h ff.c ff.h ffconf.h integer.h mmc.c rtc.c rtc.h
  group MDR32F9Qx_FWLib
    ../../../../Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_eth.c MDR32F9Qx_iwdg.c MDR32F9Qx_mil_std_1553.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group MDR32F9Qx_USBLib
    ../../../../Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group Target
    ../../../../Libraries/CMSIS/CM1/DeviceSupport/MDR1986VE1T/startup/iar/: startup_MDR1986VE1T.s system_MDR1986VE1T.c system_MDR1986VE1T.h
  group User
    ../../src/: adc.c Demo_Init_MDR1986VE1T.c gl.c joystick.c lcd_MDR1986VE1T.c leds.c Main.c MDR1986VE1T_it.c Menu.c Menu_gl.c Menu_leds.c Menu_lowpower.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_VCOM.c systick.c text.c
    ../../inc/: lcd.h
